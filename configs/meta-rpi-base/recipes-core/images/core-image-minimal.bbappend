# Dummy bbappend to prevent Yocto warning about empty layer
